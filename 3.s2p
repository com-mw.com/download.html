! 3/6/2025 3:19:56 PM
! C:\USERS\VECTORSTARUSER\DESKTOP\NEW FOLDER\3.S2P
! CHANNEL.1
! TR.MEASUREMENT
! CORRECTED.DATA
! RF.CORRECTION: FULL.TWO.PORT.CAL.PORT.1.2
! AVERAGING.OFF
! IF.BANDWIDTH: NO.IFBW
! SWEEPTYPE:  FREQ.SWEEP(Linear)
! Reference Plane Port Info
! PORT:  PORT1  PORT2
! DISTANCE:  0  m  0  m
! TIME:  0  s  0  s
! PHASE.OFFSET:  0 °  0 °
! LOSS:  0  dB  0  dB
! REF.LOSS:  0  dB  0  dB
! REF.FREQ:  0  Hz  0  Hz
! Power Info
! POWER:  -10  dBm  -10  dBm
! EFF.POWER:  -10  dBm  -10  dBm
! SOURCE.ATTEN:  0  dB  0  dB
! TEST.ATTEN:  0  dB  0  dB
# GHZ S RI R 50.0
! FREQ.GHZ  S11RE  S11IM  S21RE  S21IM  S12RE  S12IM  S22RE  S22IM
!; PortSelection: Port_12
! Worked out from all points (weakly coupled two-port):
!   1001 points, 21 GHz to 34 GHz, reference 50 ohm
!   highest |S21| = -56.36 dB at 33.92 GHz (marker M1); lowest = -89.4 dB at 21.9 GHz (marker M2)
!   lowest |S11| = -63.3 dB at 24.5 GHz (marker M3), VSWR 1.00, Z = 50 - j0.0619 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -43.7 to -16.2 dB; largest |S21 - S12| = 0.0006
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 21 GHz  -28.6  -64.6  -63.9  -17.4
! 21.75 GHz  -30.3  -69.7  -70.7  -19.3
! 21.9 GHz  -32.2  -89.4  -69.0  -19.5
! 21.98 GHz  -33.6  -72.2  -67.6  -19.7
! 22.11 GHz  -36.5  -66.8  -71.3  -20.0
! 22.25 GHz  -38.7  -62.9  -65.5  -20.3
! 22.69 GHz  -30.6  -63.7  -63.9  -20.6
! 23.17 GHz  -29.7  -60.5  -64.0  -19.4
! 23.91 GHz  -42.2  -64.1  -65.8  -17.5
! 24.5 GHz  -63.3  -64.5  -62.5  -16.8
! 24.82 GHz  -47.5  -62.2  -64.4  -16.6
! 25.34 GHz  -38.8  -65.4  -63.9  -16.2
! 26.02 GHz  -35.4  -64.4  -65.6  -16.5
! 26.82 GHz  -39.6  -64.0  -63.8  -18.1
! 27.5 GHz  -35.3  -62.7  -67.1  -19.6
! 29.67 GHz  -37.3  -62.5  -63.1  -25.2
! 30.31 GHz  -34.3  -60.3  -59.8  -26.1
! 31.1 GHz  -33.3  -71.5  -68.8  -27.5
! 31.84 GHz  -30.2  -68.3  -63.4  -27.3
! 33.34 GHz  -28.0  -61.3  -59.7  -27.5
! 33.92 GHz  -30.6  -56.4  -59.0  -33.5
! 34 GHz  -26.3  -57.2  -58.2  -33.2
